# Keil uVision project nerc_uv.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32H563RGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: nerc_uv
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  group Rotator_CTRL
    ./src/: main_rtx.c stdout_USART.c rotator.c drv8701.c n1mm_xml_parser.c adc.c config.c flash_io.c
  group Network
    ./src/: network.c Telnet_Server_UIF.c
  group WEB_Server
    ./src/: HTTP_Server_Access.c HTTP_Server_CGI.c
    Web/: Web.c
  group web
    ./web/: style.css banner_s54MTB.png index.html network-settings.cgi system-settings.cgi calibration.cgi motor-settings.cgi motor-settings.htm manual-operation.cgi status.cgi
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target 1/STM32CubeMX/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c system_stm32h5xx.c
    ./STM32CubeMX/Target 1/STM32CubeMX/MDK-ARM/: startup_stm32h563xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target 1/STM32CubeMX/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:Ethernet MAC 3.0.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Compiler:I/O:STDOUT 1.2.0, Device:CubeMX 1.0.0, Network:CORE 8.0.0, Network:Interface:ETH 8.0.0, Network:Service:Telnet Server 8.0.0, Network:Service:Web Server Compact 8.0.0, Network:Socket:TCP 8.0.0, Network:Socket:UDP 8.0.0
